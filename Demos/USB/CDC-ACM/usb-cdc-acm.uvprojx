# Keil uVision project usb-cdc-acm.uvprojx, settings and files
target usb-cdc-acm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: usb-cdc-acm
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\Drivers\CMSIS\Include;..\..\..\Drivers\CMSIS\Device\Air105\Include;..\..\..\Drivers\Air105_StdPeriph_Driver\inc;.\Library\inc;.\User;.\CherryUSB\core;.\CherryUSB\common;.\CherryUSB\class\cdc;.\CherryUSB\port\musb
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Startup
    ../../../Drivers/CMSIS/Device/Air105/Source/ARM/: startup_air105.s
  group CMSIS
    ../../../Drivers/CMSIS/Device/Air105/Source/: system_air105.c
  group StdPeriphLib
    ../../../Drivers/Air105_StdPeriph_Driver/src/: air105_adc.c air105_cache.c air105_crc.c air105_dac.c air105_dcmi.c air105_dma.c air105_exti.c air105_gpio.c air105_hspim.c air105_i2c.c air105_kcu.c air105_lcdi.c air105_otp.c air105_qspi.c air105_rtc.c air105_spi.c air105_sysctrl.c air105_timer.c air105_trng.c air105_uart.c air105_wdt.c misc.c
  group User
    ./User/: main.c air105_it.c usb_cdc_acm.c
  group Library
    ./Library/src/: delay.c sysc.c usart.c
  group CherryUSB
    ./CherryUSB/class/cdc/: usbd_cdc.c
    ./CherryUSB/core/: usbd_core.c
    ./CherryUSB/port/musb/: usb_dc_musb.c
